# Keil uVision project test.uvprojx, settings and files
target test (6120000::V6.12::.\ARMCLANG)
  device: MM32L373PF MindMotion
  pack: MindMotion.MM32L3xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\MM32L3xx\Include;..\MODULE\utilities;..\MODULE\utilities\preprocessor;..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../MM32L3xx/Source/KEIL_StartAsm/: startup_MM32L3xx.s
  group Bsp
    ../BSP/led/: led.c led.h
    ../BSP/uart/: uart.c uart.h
  group System
    ../SYSTEM/: sys.c sys.h
  group Module
    ../MODULE/critical/: critical.c critical.h
    ../MODULE/event/: event.c event.h
    ../MODULE/mailbox/: mailbox.c mailbox.h
    ../MODULE/utilities/: ooc.h compiler.h simple_fsm.h
  group User
    ../USER/: main.c
  group Drive
    ../DRIVE/uart/: drv_uart.c drv_uart.h
software components: CMSIS:CORE 5.2.0
